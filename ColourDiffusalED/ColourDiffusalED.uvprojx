# Keil uVision project ColourDiffusalED.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ColourDiffusal
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: __TARGET_FPU_SOFTVFP
  c include: .\Inc;..\stm32f411cex_bsp;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\Peripherals;..\qpc\include;..\qpc\kernels\ucosii
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ./Inc/: main.h stm32f4xx_it.h
    ./Src/: main.c stm32f4xx_it.c app.c app.h central.c central.h tickerkeeper.c tickerkeeper.h
  group stm32f411cex_bsp
    ../stm32f411cex_bsp/: bsp_gpio.c bsp_gpio.h bsp_i2c.c bsp_i2c.h bsp_system.c bsp_system.h bsp_spi.c bsp_spi.h
  group UCOSII-CORE
    ../UCOSII/CORE/: includes.h os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: app_cfg.h app_hooks.c os_cfg.h
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Pheripherals
    ../Peripherals/: sdd1306.c sdd1306.h veml6040.c veml6040.h sdd1306_font.h
  group qp_src
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group qp_port
    ../qpc/kernels/ucosii/: qf_port.c qp_port.h qs_port.h
  group qp_includes
    ../qpc/include/: qequeue.h qk.h qmpool.h qp.h qp_pkg.h qpc.h qs.h qs_dummy.h qs_pkg.h qsafe.h qstamp.h qv.h qxk.h
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
